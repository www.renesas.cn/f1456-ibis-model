| IBIS file created by T2B Version 15.0.2.03101 S001
| Cadence Design Systems, Inc. 2011
[IBIS ver] 2.1
[File name]  F1456_in.ibs
[File Rev]  0.1
[Date]   October 23, 2017
[Source] Integrated Device Technology, Inc.
|   Component dummycomp
F|
[Component] dummycomp
[Manufacturer] Integrated Device Technology, Inc.
[Package]
| variable   typ   min   max
R_pkg   2.000m   1.000m   4.000m
L_pkg   0.200nH   0.100nH   0.400nH
C_pkg   2.000pF   1.000pF   4.000pF
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
in in   F1456_inBuf
gnd   gnd   GND
Vcc   Vcc   POWER
|   Model f1455-in
[Model] F1456_inBuf
Model_type Input
Polarity   Non-Inverting
Vinl =  0.800V
Vinh =  1.100V
C_comp   0.0F   0.0F   0.0F
[Temperature Range]   25.000   0.105k   -40.000
[Voltage Range]   5.000V   4.750V   5.250V
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| Models and submodels in the file (1): F1456_inBuf (Input)
